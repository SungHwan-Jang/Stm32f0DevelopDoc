# Keil uVision project rtx_hal.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F051R8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: rtx_hal
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Group 1
    ./: main.c
software components: CMSIS:CORE 5.4.0, CMSIS:RTOS:Keil RTX 4.82.0, Device:STM32Cube HAL:ADC 1.11.0, Device:STM32Cube HAL:COMMON 1.11.0, Device:STM32Cube HAL:COMP 1.11.0, Device:STM32Cube HAL:CORTEX 1.11.0, Device:STM32Cube HAL:CRC 1.11.0, Device:STM32Cube HAL:DAC 1.11.0, Device:STM32Cube HAL:DMA 1.11.0, Device:STM32Cube HAL:EXTI 1.11.0, Device:STM32Cube HAL:FLASH 1.11.0, Device:STM32Cube HAL:GPIO 1.11.0, Device:STM32Cube HAL:I2C 1.11.0, Device:STM32Cube HAL:I2S 1.11.0, Device:STM32Cube HAL:IWDG 1.11.0, Device:STM32Cube HAL:PWR 1.11.0, Device:STM32Cube HAL:RCC 1.11.0, Device:STM32Cube HAL:RTC 1.11.0, Device:STM32Cube HAL:SPI 1.11.0, Device:STM32Cube HAL:TIM 1.11.0, Device:STM32Cube HAL:UART 1.11.0, Device:STM32Cube HAL:WWDG 1.11.0, Device:Startup 1.0.0
