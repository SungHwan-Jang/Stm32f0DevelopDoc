# Keil uVision project CubeKeilTest1.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F051R8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: CubeKeilTest1
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
software components: Device:STM32Cube HAL:ADC 1.7.0, Device:STM32Cube HAL:COMMON 1.7.0, Device:STM32Cube HAL:CORTEX 1.7.0, Device:STM32Cube HAL:DMA 1.7.0, Device:STM32Cube HAL:FLASH 1.7.0, Device:STM32Cube HAL:GPIO 1.7.0, Device:STM32Cube HAL:I2C 1.7.0, Device:STM32Cube HAL:RCC 1.7.0, Device:STM32Cube HAL:UART 1.7.0, Device:STM32Cube HAL:USART 1.7.0, Device:Startup 1.0.0
