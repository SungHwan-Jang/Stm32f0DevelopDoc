# Keil uVision project project.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F072RB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=4 OneElfS=1
  c define: STM32F072xB
  c include: ..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\Libraries\CMSIS\Device\ST\STM32F0xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group MDK
    ../../../../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f072xb.s
  group CMSIS
    ../: system_stm32f0xx.c
  group User
    ../: main.c
